## boards/shields/saketh/Kconfig.defconfig
```kconfig
if SHIELD_SAKETH

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "saketh"

endif
```
